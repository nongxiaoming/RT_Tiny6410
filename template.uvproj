# Keil uVision project template.uvproj, settings and files
target RT-Thread S3C6410 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: rtthread-tiny6410
  c flags: Optim=1
  library: MicroLIB
  memory RVCT9: RAM 0x40000000 size 0x1000
  scatter file: .\rtthread-tiny6410.sct
